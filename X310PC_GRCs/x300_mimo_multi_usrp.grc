<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>x300_tx_mimo</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>2.467e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_base_str</value></param>
<param><key>value</key><value>"/mnt/ramdisk/uhd_ofdm_tx_4user_coded_QAM16_12r"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain1</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain2</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_0_0</value></param>
<param><key>file</key><value>file_base_str+"_3.dat"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_2</value></param>
<param><key>file</key><value>file_base_str+"_0.dat"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_2_0</value></param>
<param><key>file</key><value>file_base_str+"_1.dat"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_2_0_0</value></param>
<param><key>file</key><value>file_base_str+"_2.dat"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_selector</key>
<param><key>id</key><value>blocks_selector_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>enabled</key><value>True</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain1</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
<param><key>bw1</key><value>samp_rate</value></param>
<param><key>center_freq1</key><value>center_freq</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>gain2</value></param>
<param><key>ant2</key><value>TX/RX</value></param>
<param><key>bw2</key><value>samp_rate</value></param>
<param><key>center_freq2</key><value>center_freq</value></param>
<param><key>norm_gain2</key><value>False</value></param>
<param><key>gain2</key><value>gain2</value></param>
<param><key>ant3</key><value>TX/RX</value></param>
<param><key>bw3</key><value>samp_rate</value></param>
<param><key>center_freq3</key><value>center_freq</value></param>
<param><key>norm_gain3</key><value>False</value></param>
<param><key>gain3</key><value>gain2</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.10.2,addr1=192.168.11.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>sd_spec0</key><value>A:0 B:0</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>clock_source1</key><value>external</value></param>
<param><key>sd_spec1</key><value>A:0 B:0</value></param>
<param><key>time_source1</key><value>external</value></param>
<param><key>nchan</key><value>4</value></param>
<param><key>num_mboards</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>start_time</key><value>-1</value></param>
<param><key>sync</key><value>sync</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>blocks_file_source_0_0_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_2</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_2_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_2_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
